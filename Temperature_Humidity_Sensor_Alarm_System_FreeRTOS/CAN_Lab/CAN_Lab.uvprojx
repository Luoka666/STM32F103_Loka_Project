# Keil uVision project CAN_Lab.uvprojx, settings and files
target CAN_Lab (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: CAN_Lab +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\User;..\Start;..\Library
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: startup_stm32f10x_md.s
    ../Start/: system_stm32f10x.c system_stm32f10x.h stm32f10x.h core_cm3.h
  group Library
    ../Library/: stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_can.c stm32f10x_can.h misc.c misc.h
  group User
    ./User/: main.c stm32f10x_conf.h
